options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Prototype Jr
  states: {}

blocks:
- name: gain_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: gain_1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_interleaved_char_1
  id: blocks_complex_to_interleaved_char
  parameters:
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/aviguardx/Documents/passiveRadar/data/drone_tests_2/fixHeightTest7/output2
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/aviguardx/Documents/passiveRadar/data/drone_tests_2/fixHeightTest7/output1
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '128'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '560000000'
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    nconnections: '2'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    ant0: '0'
    args: rtl=0
    bb_gain0: '20'
    freq0: '560000000'
    gain0: gain_0
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_1
  id: rtlsdr_source
  parameters:
    ant0: '1'
    args: rtl=1
    bb_gain0: '20'
    freq0: '560000000'
    gain0: gain_1
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_interleaved_char_1, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', qtgui_histogram_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_interleaved_char_1, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_1, '0', blocks_complex_to_real_1, '0']
- [rtlsdr_source_1, '0', blocks_multiply_const_vxx_1, '0']
- [rtlsdr_source_1, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
